# Keil uVision project Mainboard.uvprojx, settings and files
target Mainboard (6120000::V6.12::.\ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Mainboard +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ..\User\Inc;..\Hal\CMSIS\Device;..\Hal\STM32F4xx_HAL_Driver\Inc;..\Hal\STM32F4xx_HAL_Driver\Inc\Legacy;..\Driver;..\Application\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/Src/: main.c cpu.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Task
    ../User/Src/: DbgPrint.c
    ../Application/Source/: Motor.c Attitude.c Stabilizer.c Battery.c
  group Algorithm
    ../User/Src/: FFT.c Filter.c Mymath.c
    ../Application/Source/: PID.c
  group Driver
    ../Driver/: MPU6000.c BMP280.c LSM303D.c NRF24L01.c LORA433.c
  group Hal
    ../User/: startup_stm32f405xx.s
    ../User/Src/: system_stm32f4xx.c
    ../Hal/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c
software components: CMSIS:CORE 5.2.0
