# Keil uVision project HyTelectrl.uvprojx, settings and files
target HyTelectrl (6160000::V6.16::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HyTelectrl +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,STM32F4
  c include: ..\Application;..\Driver;..\Library\CMSIS;..\Library\STM32F4xx_HAL_Driver\Inc;..\Library\STM32F4xx_HAL_Driver\Inc\Legacy;..\User;..\GUILib;..\GUILib\src\hal;..\GUIApp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f429xx.s cpu.c
  group Library
    ../Library/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_mmc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_lptim.c stm32f4xx_hal_nand.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c
  group Driver
    ../Driver/: sdram.c ltdc.c ADC.c NRF24L01.c
  group Task
    ../Application/: Power.c Communi.c
  group GUILib
    ../GUILib/: lv_conf.h lvgl.h lv_port_disp.c lv_port_fs.c lv_port_indev.c
    ../GUILib/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../GUILib/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../GUILib/src/extra/: lv_extra.c
    ../GUILib/src/extra/layouts/flex/: lv_flex.c
    ../GUILib/src/extra/layouts/grid/: lv_grid.c
    ../GUILib/src/extra/libs/bmp/: lv_bmp.c
    ../GUILib/src/extra/libs/freetype/: lv_freetype.c
    ../GUILib/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../GUILib/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../GUILib/src/extra/libs/png/: lodepng.c lv_png.c
    ../GUILib/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../GUILib/src/extra/libs/rlottie/: lv_rlottie.c
    ../GUILib/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../GUILib/src/extra/others/snapshot/: lv_snapshot.c
    ../GUILib/src/extra/themes/basic/: lv_theme_basic.c
    ../GUILib/src/extra/themes/default/: lv_theme_default.c
    ../GUILib/src/extra/themes/mono/: lv_theme_mono.c
    ../GUILib/src/extra/widgets/animimg/: lv_animimg.c
    ../GUILib/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../GUILib/src/extra/widgets/chart/: lv_chart.c
    ../GUILib/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../GUILib/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../GUILib/src/extra/widgets/keyboard/: lv_keyboard.c
    ../GUILib/src/extra/widgets/led/: lv_led.c
    ../GUILib/src/extra/widgets/list/: lv_list.c
    ../GUILib/src/extra/widgets/meter/: lv_meter.c
    ../GUILib/src/extra/widgets/msgbox/: lv_msgbox.c
    ../GUILib/src/extra/widgets/span/: lv_span.c
    ../GUILib/src/extra/widgets/spinbox/: lv_spinbox.c
    ../GUILib/src/extra/widgets/spinner/: lv_spinner.c
    ../GUILib/src/extra/widgets/tabview/: lv_tabview.c
    ../GUILib/src/extra/widgets/tileview/: lv_tileview.c
    ../GUILib/src/extra/widgets/win/: lv_win.c
    ../GUILib/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_24.c lv_font_montserrat_32.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../GUILib/src/gpu/: lv_gpu_stm32_dma2d.c
    ../GUILib/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUILib/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../GUILib/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group GUIApp
    ../GUIApp/: GUI_Main.c
software components: CMSIS:CORE 5.5.0
